v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {ota_p_in.sym} 60 40 0 0 {name=x1}
